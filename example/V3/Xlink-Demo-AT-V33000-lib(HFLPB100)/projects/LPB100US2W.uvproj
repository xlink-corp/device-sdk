# Keil uVision project LPB100US2W.uvproj, settings and files
target LPB100US2W (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPB100US2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPB100US2W.bin ./output/LPB100US2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPB100US2W.bin ./output/LPB100US2W_UPGARDE.bin
  c flags: Optim=1 OneElfS=1
  c define: __KEIL_MDK__ __LPB100U__
  c misc: --diag_suppress=494  --c99
  c include: ..\sdk\1.50\include;..\xlink
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c xlink_Application.c xlink_at.c xlink_config.c xlink_Demo.c xlink_oat_hf.c
  group libs
    ../sdk/1.50/libs/: LPB100UKernel.lib LPB100US2W_V11181_1024.lib
