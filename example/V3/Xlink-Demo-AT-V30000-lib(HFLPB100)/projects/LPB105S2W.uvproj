# Keil uVision project LPB105S2W.uvproj, settings and files
target LPB105S2W (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPB105S2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPB105S2W.bin ./output/LPB105S2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPB105S2W.bin ./output/LPB105S2W_UPGARDE.bin
  c flags: OneElfS=1
  c define: __KEIL_MDK__ __LPB105__
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.50/include/;..\xlink;..\src
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c xlink_Application.c xlink_at.c xlink_config.c xlink_Demo.c xlink_oat_hf.c
  group libs
    ../sdk/1.50/libs/: LPB100Kernel.lib
    ../xlink/: Xlink-lib-LPB100-V24002.lib
